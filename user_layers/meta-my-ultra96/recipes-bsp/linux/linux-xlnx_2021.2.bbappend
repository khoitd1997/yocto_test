# FILESEXTRAPATHS_append_my-ultra96-zynqmp := "${THISDIR}:"

# SRC_URI_append_my-ultra96-zynqmp = " \
#         file://my-ultra96-kmeta;type=kmeta;destsuffix=my-ultra96-kmeta \
#         "