FILESEXTRAPATHS_append := "${THISDIR}:"

SRC_URI_append = " \
        file://my-ultra96-kmeta;type=kmeta;destsuffix=my-ultra96-kmeta \
        "