require qemu-xilinx-common.inc

DEPENDS += " pmu-rom-qemu "