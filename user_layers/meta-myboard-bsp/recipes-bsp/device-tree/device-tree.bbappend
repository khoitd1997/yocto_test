FILESEXTRAPATHS_prepend_my-zcu102-zynqmp := "${THISDIR}/files:"

EXTRA_OVERLAYS_append_my-zcu102-zynqmp = " top.dtsi "