# enable debugging prints
YAML_COMPILER_FLAGS_append = " ${XSCTH_COMPILER_DEBUG_FLAGS} -DPM_LOG_LEVEL=3 "