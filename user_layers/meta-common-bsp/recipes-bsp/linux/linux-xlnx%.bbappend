inherit kconfig-cusomization