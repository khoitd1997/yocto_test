require kconfig-cusomization.inc